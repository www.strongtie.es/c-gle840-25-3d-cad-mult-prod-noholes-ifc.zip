Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:06:41
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:06:41 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C3320BEE-ACFC-441F-A81C-2B9F19665C1F}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:06:41 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:06:41 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:06:41 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_142_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0

# IfcBuildingElementProxy: C_GLE840_142_25_3D_CAD_MULT_Prod_noholes, C_GLE840_142_25_3D_CAD_MULT_Prod_noholes:C_GLE840_142_25_3D_CAD_MULT_Prod_noholes:219338
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00674929 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/142/2.5
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Model ID: 0253753702738360917401852503615459694953; ObjectType: GLE840/142/2.5; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE840/142/2.5; Name: GLE840/142/2.5; Product Type: Joist hanger; URL: www.strongtie.eu
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE840/142/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.49; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
