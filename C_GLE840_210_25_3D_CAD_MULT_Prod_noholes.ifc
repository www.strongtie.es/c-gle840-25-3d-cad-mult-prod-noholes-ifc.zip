Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:07:02
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:07:02 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C336D405-C2A4-4205-B920-B00FF94EB2C5}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:07:02 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:07:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:07:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_210_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Line Weight: 1; Symbol at End 1 Default: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GLE840_210_25_3D_CAD_MULT_Prod_noholes, C_GLE840_210_25_3D_CAD_MULT_Prod_noholes:C_GLE840_210_25_3D_CAD_MULT_Prod_noholes:240690
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00673163 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/210/2.5
Identity Data - OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Model ID: 0184636633445004025554855371703810213570; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Model: GLE840/210/2.5; UniClass Title: Joist hangers; ObjectType: GLE840/210/2.5; URL: www.strongtie.eu; Name: GLE840/210/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Product Type: Joist hanger; Description: Joist hanger
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE840/210/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.49
Materials and Finishes - Product Material: Galvanised
