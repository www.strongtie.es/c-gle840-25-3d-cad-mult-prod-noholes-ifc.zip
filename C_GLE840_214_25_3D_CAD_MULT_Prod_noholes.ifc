Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:07:03
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:07:03 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{03347BE0-15A8-499B-AA99-C07FEB411F46}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:07:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:07:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:07:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_214_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GLE840_214_25_3D_CAD_MULT_Prod_noholes, C_GLE840_214_25_3D_CAD_MULT_Prod_noholes:C_GLE840_214_25_3D_CAD_MULT_Prod_noholes:241946
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00673163 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/214/2.5
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE840/214/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.49; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Description: Joist hanger; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Name: GLE840/214/2.5; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; ObjectType: GLE840/214/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE840/214/2.5; OmniClass Title: Wood Connectors; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Model ID: 0184636633445004025554855371703810213570; UniClass Number: Pr_20_29_31_44
Materials and Finishes - Product Material: Galvanised
