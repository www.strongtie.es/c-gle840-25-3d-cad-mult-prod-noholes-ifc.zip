Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:06:12
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:06:12 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{82B92C6A-77E3-4546-8D03-A3FEDB0B5232}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:06:11 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:06:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:06:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_48_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GLE840_48_25_3D_CAD_MULT_Prod_noholes, C_GLE840_48_25_3D_CAD_MULT_Prod_noholes:C_GLE840_48_25_3D_CAD_MULT_Prod_noholes:189822
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00674929 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/48/2.5
General - Reference: GLE840/48/2.5; Density: 1.49; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Model ID: 0253753702738360917401852503615459694953; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Name: GLE840/48/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; Model: GLE840/48/2.5; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; ObjectType: GLE840/48/2.5; URL: www.strongtie.eu; Description: Joist hanger
Materials and Finishes - Product Material: Galvanised
