Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:06:19
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:06:19 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B73DB0FE-6775-4741-B74A-762FAFE18B71}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:06:19 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:06:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:06:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_72_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0; Line Weight: 1

# IfcBuildingElementProxy: C_GLE840_72_25_3D_CAD_MULT_Prod_noholes, C_GLE840_72_25_3D_CAD_MULT_Prod_noholes:C_GLE840_72_25_3D_CAD_MULT_Prod_noholes:197358
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00674929 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/72/2.5
Identity Data - Name: GLE840/72/2.5; Model ID: 0253753702738360917401852503615459694953; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Model: GLE840/72/2.5; ObjectType: GLE840/72/2.5; UniClass Number: Pr_20_29_31_44; Description: Joist hanger; Product Type: Joist hanger; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; Manufacturer: Simpson Strong-Tie
General - Reference: GLE840/72/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.49
Materials and Finishes - Product Material: Galvanised
