Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:07:00
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:07:00 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C0E74EA7-4D9D-494E-819A-34E3D90E58E5}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:07:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:07:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:07:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE840_204_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GLE840_204_25_3D_CAD_MULT_Prod_noholes, C_GLE840_204_25_3D_CAD_MULT_Prod_noholes:C_GLE840_204_25_3D_CAD_MULT_Prod_noholes:238806
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00673163 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/204/2.5
Identity Data - URL: www.strongtie.eu; OmniClass Number: 23.20.40.11.24.14; Name: GLE840/204/2.5; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0184636633445004025554855371703810213570; Product Type: Joist hanger; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; ObjectType: GLE840/204/2.5; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Model: GLE840/204/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com
Materials and Finishes - Product Material: Galvanised
General - Reference: GLE840/204/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.49; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
